FILES_${PN} = "/usr/lib/locale"

require glibc-locale.inc

